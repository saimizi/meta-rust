require rust-source.inc
require rust-snapshot.inc
require cargo.inc
BBCLASSEXTEND = "native nativesdk"
